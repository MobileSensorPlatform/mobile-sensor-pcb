# Repository MobileSensorPlatform/mobile-sensor-pcb

## KiCad design mobile-sensor-pcb.kicad_pcb

Parts:
BT1: Battery; CR1220
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 10uF; C_1206_HandSoldering
C13, C14, C15, C16: 100nF; C_1206_HandSoldering
C17, C18, C19: 10nF; C_1206_HandSoldering
C20: 100uF; C_1206_HandSoldering
C21: 2.2uF; C_1206_HandSoldering
D1: MBR120VLSFT1G; SOD-123
F1: 500 mA fuse; Fuse_SMD1206_HandSoldering
FB1, FB2, FB3, FB4, FB5, FB6, FB7: FILTER; R_0805_HandSoldering
J1: SMA
J2: USB_OTG; USB-micro-B-female
J3: JST PH; s2b-ph-sm4-tb
L1: 6.8uH; Neosid_Inductor_SM-NE56_SMD2220
LED1: RX; LED-0805
LED2: TX; LED-0805
LED3: SIG; LED-0805
LED4, LED11: PWR; LED-0805
LED5: CONN; LED-0805
LED6: 5V; LED-0805
LED7: FULL; LED-0805
LED8: CHG; LED-0805
LED9: DEAD; LED-0805
LED10: LOG; LED-0805
LED12: FIX; LED-0805
Q1: PNP-BJT-BIASED_SOT; SOT-23_Handsoldering
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 1K; R_0805_HandSoldering
R13, R14, R15, R16, R17, R18, R19: 10k; R_0805_HandSoldering
R20, R21: 340k; R_0805_HandSoldering
R22: 200k; R_0805_HandSoldering
R23, R24: 1.80M; R_0805_HandSoldering
R25: 2k; R_0805_HandSoldering
SHIELD1: ARDUINO_DUE_SHIELD
SW1: RESET; SW_PUSHBUTTON_SMD
SW2: ON/OFF; SCREWTERMINAL-3.5MM-2
TC1, TC2, TC3: SCREW TERMINAL; SCREWTERMINAL-3.5MM-2
U1: 3M_2908-05WB-MG
U2: 74HC4050; SOIC-16_3.9x9.9mm_Pitch1.27mm
U3: FGPMMOPA6H
U4: RT9193; SOT-23-5
U5: MIC5219; SOT-23-5
U6: MCP73831T-2ACI/OT; SOT-23-5
U7, U8, U9: MAX31855KASA; SOIC-8_3.9x4.9mm_Pitch1.27mm
U10, U11, U12: LP2980AIM5-3.3/NOPB; SOT-23-5
U13: TPS61030RSA; QFN-16-1EP_4x4mm_Pitch0.65mm
X1: XBEE; XBEE_PRO

Connections:
BATT-5V: C1.1, C9.1, D1.1 (K), LED6.2 (A), Q1.2 (E), SHIELD1.5V, SHIELD1.5V_4, SHIELD1.5V_5, U4.1 (VIN), U4.3 (EN), U5.1 (IN), U5.3 (EN), U10.1 (VIN), U10.3 (EN), U11.1 (VIN), U11.3 (EN), U12.1 (VIN), U12.3 (EN)
BATT-DEAD: LED9.2 (A), Q1.3 (C)
BATT-STAT: LED7.2 (A), R8.2, U6.1 (STAT)
GND: BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C20.2, C21.2, J1.2 (GND1), J1.3 (GND2), J1.4 (GND3), J1.5 (GND4), J2.5 (GND), J2.6 (shield), J3.2, R3.2, R4.2, R5.2, R6.2, R7.2, R9.2, R10.2, R11.2, R12.2, R20.2, R22.2, R25.2, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SHIELD1.GND4, SHIELD1.GND5, SHIELD1.SP6 (Gnd), SW1.2, SW2.1, U1.6 (GND), U1.9 (GND), U2.8 (VSS), U3.3 (GND), U3.19 (GND), U4.2 (GND), U5.2 (GND), U6.2 (VSS), U7.1 (GND), U8.1 (GND), U9.1 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.5 (PGND), U13.6 (PGND), U13.7 (PGND), U13.10 (SYNC), U13.13 (GND), U13.17 (PAD), X1.10 (GND)
GPS-3V3-RX: U2.12 (5Y), U3.10 (RX)
GPS-5V-RX: SHIELD1.19 (RX1), U2.11 (5A)
GPS-FIX: LED12.2 (A), U3.5 (3DFIX)
GPS-SD-3V3: C10.1, FB7.1, LED11.2 (A), R19.1, U1.4 (VCC), U2.1 (VDD), U4.5 (VOUT)
GPS-TX: SHIELD1.18 (TX1), U3.9 (TX)
unnamed: BT1.1, U3.4 (VBACKUP)
unnamed: C3.1, C4.1, R13.1, R14.1, U7.4 (VCC), U10.5 (VOUT)
unnamed: C5.1, C6.1, R15.1, R16.1, U8.4 (VCC), U11.5 (VOUT)
unnamed: C7.1, C8.1, R17.1, R18.1, U9.4 (VCC), U12.5 (VOUT)
unnamed: C11.1, C13.1, J3.1, L1.1, R21.2, R24.1, U6.3 (VBAT), U13.8 (VBAT)
unnamed: C15.2, X1.17 (AD3/DIO3)
unnamed: C16.1, FB7.2, U3.1 (VCC)
unnamed: C17.1, FB1.2, U7.3 (T+)
unnamed: C17.2, FB2.2, U7.2 (T-)
unnamed: C18.1, FB3.2, U8.3 (T+)
unnamed: C18.2, FB4.2, U8.2 (T-)
unnamed: C19.1, FB5.2, U9.3 (T+)
unnamed: C19.2, FB6.2, U9.2 (T-)
unnamed: C20.1, C21.1, F1.2, R23.1, U13.1 (VOUT), U13.15 (VOUT), U13.16 (VOUT)
unnamed: D1.2 (A), F1.1
unnamed: FB1.1, TC1.2
unnamed: FB2.1, TC1.1
unnamed: FB3.1, TC2.2
unnamed: FB4.1, TC2.1
unnamed: FB5.1, TC3.2
unnamed: FB6.1, TC3.1
unnamed: J1.1 (RF), U3.11 (EX_ANT)
unnamed: L1.2, U13.2 (SW), U13.3 (SW)
unnamed: LED1.1 (K), R1.1
unnamed: LED2.1 (K), R2.1
unnamed: LED3.1 (K), R3.1
unnamed: LED4.1 (K), R4.1
unnamed: LED5.1 (K), R5.1
unnamed: LED6.1 (K), R6.1
unnamed: LED7.1 (K), R7.1
unnamed: LED8.1 (K), R8.1
unnamed: LED9.1 (K), R9.1
unnamed: LED10.1 (K), R10.1
unnamed: LED11.1 (K), R11.1
unnamed: LED12.1 (K), R12.1
unnamed: Q1.1 (B), U13.12 (LBO)
unnamed: R20.1, R24.2, U13.9 (LBI)
unnamed: R21.1, SW2.2, U13.11 (EN)
unnamed: R22.1, R23.2, U13.14 (FB)
unnamed: R25.1, U6.5 (PROG)
unnamed: U1.2 (DAT3/CD/CS), U2.6 (3Y)
unnamed: U1.3 (CMD/DI), U2.4 (2Y)
unnamed: U1.5 (CLK), U2.2 (1Y)
SD-CLK: LED10.2 (A), SHIELD1.50 (PB3), U2.3 (1A)
SD-CS: R19.2, SHIELD1.44 (PL5), U2.7 (3A)
SD-MISO: SHIELD1.48 (PL1), U1.7 (DAT0/DO)
SD-MOSI: SHIELD1.46 (PL3), U2.5 (2A)
TC-CS0: R14.2, SHIELD1.10, U7.6 (~CS~)
TC-CS1: R16.2, SHIELD1.4, U8.6 (~CS~)
TC-CS2: R18.2, SHIELD1.52 (PB1), U9.6 (~CS~)
TC-MISO: SHIELD1.SP1 (MISO), U7.7 (SO), U8.7 (SO), U9.7 (SO)
TC-SCK: R13.2, R15.2, R17.2, SHIELD1.SP3 (SCK), U7.5 (SCK), U8.5 (SCK), U9.5 (SCK)
USB-5V: C12.1, J2.1 (VCC), LED8.2 (A), U6.4 (VDD)
XBEE-3V3: C2.1, C14.1, LED1.2 (A), LED2.2 (A), LED4.2 (A), U5.5 (OUT), X1.1 (VCC)
XBEE-DIO5: LED5.2 (A), X1.15 (AD5/DIO5)
XBEE-RESET: C15.1, SHIELD1.RST, SW1.1
XBEE-RSSI: LED3.2 (A), X1.6 (PWM0/RSSI)
XBEE-RX: R1.2, SHIELD1.17 (RX2), X1.2 (DOUT)
XBEE-TX: R2.2, SHIELD1.16 (TX2), X1.3 (DIN/~CONFIG)

Board: 2 copper layers, 125.7 x 67.6 mm, 93 parts (0 on the bottom side), 68 nets.

## Commit log

2015-09-07 Start BOM
2015-09-07 Finish first cut at BOM
2015-09-07 Add thermocouple amps and fix a few omissions
2015-09-09 Update BOM details
2015-09-09 First complete version of BOM
2015-09-09 Add PCB footprints
2015-09-10 Start PCB layout
2015-09-11 Add more components and footprints
2015-09-11 Add submodules
2015-09-17 More components added
2015-09-17 More components, plus update footprint library rev
2015-09-18 More components, more footprints
2015-09-21 First commit with all footprints added
2015-09-23 Start connecting stuff. Still need a few more resistors.
2015-09-24 Schematic done
2015-09-25 Fix a few bad connections, start to lay out PCB
2015-09-29 Arrange thermocouple amps
2015-10-01 Add script for placing LEDs in an arc
2015-10-01 Tweak LED layout a little
2015-10-02 More routing
2015-10-06 Route all but thermocouples. Add LED arc screenshots.
2015-10-08 Minor PCB fixes. Rework BOM to have fewer distributors. Change battery holder part.
2015-10-08 Remove power switch and reset headers. Split BOM into orders.
2015-11-04 Fix a R19 connection, spin SD card holder, fix SMA jack
2015-11-04 Update footprint submodule
2015-11-09 Lots of little tweaks, rounding corners, fixing designators, adding labels, name, date and rev
2015-11-10 Create gerbers and release zipball
2015-11-11 Generate forgotten soldermask layers
2015-12-10 Add BOMs and what appear to be some final PCB changes
